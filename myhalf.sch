File: myhalf.sch (EAGLE design)
At the start: 20 parts

Commit message: V1.00
Other:
- note added: "/home/kimmo/Kuvat/jollalogo.bmp"
